## src/modules/drobot_att_control/Kconfig
```kconfig
menuconfig MODULES_DROBOT_ATT_CONTROL
    bool "drobot_att_control"
    default n
```
